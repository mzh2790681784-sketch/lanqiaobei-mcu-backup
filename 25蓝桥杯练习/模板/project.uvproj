# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c system.h drive.c drive.h uart.c uart.h
  group xieyi
    ./: onewire.c onewire.h iic.c iic.h ds1302.c ds1302.h
  group waishe
    ./: smg.c smg.h key.c key.h csb.c csb.h
