# Keil uVision project 16518591.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 16518591 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c system.h drive.c drive.h
  group xieyi
    ./: iic.c iic.h onewire.c onewire.h
  group waishe
    ./: smg.c smg.h key.c key.h csb.c csb.h
