# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c system.h drive.c drive.h delay.c delay.h Timer.c Timer.h Uart.c Uart.h
  group xieyi
    ./: onewire.c onewire.h I2C.c I2C.h DS1302.c DS1302.h
  group waishe
    ./: SMG.c SMG.h key.c key.h CSB.c CSB.h
