# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c system.h drive.c drive.h uart.c uart.h
  group xieyi
    ./: i2c.c i2c.h onewire.c onewire.h
  group waishe
    ./: key.c key.h smg.c smg.h
